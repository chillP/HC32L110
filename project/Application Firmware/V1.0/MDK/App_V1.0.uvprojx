# Keil uVision project App_V1.0.uvprojx, settings and files
target App_V1.0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32L110C6UA HDSC
  pack: HDSC.HC32L110.1.0.3
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: app_V1.0
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=Bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;..\..\..\..\midware;..\..\..\..\lorawan;..\..\..\..\application
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l110.s
    ../../../../mcu/common/: system_hc32l110.c
  group application
    ../source/: main.c
    ../../../../application/: app.c
  group driver
    ../../../../driver/src/: ddl.c interrupts_hc32l110.c clk.c lpuart.c bt.c lpm.c gpio.c uart.c lpt.c pca.c wdt.c adt.c
  group readme
    ../: readme.txt
  group lorawan
    ../../../../lorawan/: LSD_LoRaWAN_ICA_Driver.c
  group midware
    ../../../../midware/: commonfun.c driver_mid.c HDEE5.c
software components: CMSIS:CORE 4.3.0
